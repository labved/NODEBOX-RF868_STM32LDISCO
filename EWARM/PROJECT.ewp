# IAR project PROJECT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RC ST STM32L152RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MDP
  ICCARM.CCIncludePath2: ..; settings; Debug; ../CMSIS; ../CONFIG_MANUAL; ../STD_PERIPH; ../USER/HAL; ../USER/HAL/HAL_W25Q; ../USER/HAL/HAL_LCD; ../USER/HAL/HAL_FATFS; ../USER/HAL/HAL_SIM800C; ../USER/HAL/HAL_E70-868T30S; ../USER/HAL/HAL_HC05; ../USER/HAL/HAL_PCF8754; ../USER/HAL/HAL_MODEL; ../USER; ../USER/SETTINGS; ../USER/SRC; ../USER/LIB; ../USER/LIB/LANG; ../USER/LIB/LIB_FLASH; ../USER/LIB/LIB_LCD; ../USER/LIB/LIB_SDMMC; ../USER/LIB/LIB_HC05; ../USER/LIB/LIB_SIM800C; ../USER/LIB/LIB_NODEBOXRF868; ../USER/LIB/LIB_PCF8574; ../USER/LIB/LIB_E70-868T30S; ../USER/LIB/LIB_MODEL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: PROJECT.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: settings/stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h system_stm32l1xx.c system_stm32l1xx.h
  group STD_PERIPH
    ../STD_PERIPH/: misc.c misc.h stm32l1xx_adc.c stm32l1xx_adc.h stm32l1xx_aes.c stm32l1xx_aes.h stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_comp.h stm32l1xx_crc.c stm32l1xx_crc.h stm32l1xx_dac.c stm32l1xx_dac.h stm32l1xx_dbgmcu.c stm32l1xx_dbgmcu.h stm32l1xx_dma.c stm32l1xx_dma.h stm32l1xx_exti.c stm32l1xx_exti.h stm32l1xx_flash.c stm32l1xx_flash.h stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_fsmc.h stm32l1xx_gpio.c stm32l1xx_gpio.h stm32l1xx_i2c.c stm32l1xx_i2c.h stm32l1xx_it.c stm32l1xx_it.h stm32l1xx_iwdg.c stm32l1xx_iwdg.h stm32l1xx_lcd.c stm32l1xx_lcd.h stm32l1xx_opamp.c stm32l1xx_opamp.h stm32l1xx_pwr.c stm32l1xx_pwr.h stm32l1xx_rcc.c stm32l1xx_rcc.h stm32l1xx_rtc.c stm32l1xx_rtc.h stm32l1xx_sdio.c stm32l1xx_sdio.h stm32l1xx_spi.c stm32l1xx_spi.h stm32l1xx_syscfg.c stm32l1xx_syscfg.h stm32l1xx_tim.c stm32l1xx_tim.h stm32l1xx_usart.c stm32l1xx_usart.h stm32l1xx_wwdg.c stm32l1xx_wwdg.h
  group USER
    ../USER/: main.cpp
  group USER/HAL/HAL_E70-868T30S
    ../USER/HAL/HAL_E70-868T30S/: HAL_E70-868T30S.cpp HAL_E70-868T30S.h
  group USER/HAL/HAL_FATFS
    ../USER/HAL/HAL_FATFS/: diskio.h ff.c ff.h ffconf.h HAL_SDCARD.c HAL_SDCARD.h integer.h mmc.c mmc.h
  group USER/HAL/HAL_HC05
    ../USER/HAL/HAL_HC05/: HAL_HC05.cpp HAL_HC05.h
  group USER/HAL/HAL_LCD
    ../USER/HAL/HAL_LCD/: HAL_LCD.cpp HAL_LCD.h
  group USER/HAL/HAL_MODEL
    ../USER/HAL/HAL_MODEL/: HAL_MODEL.cpp HAL_MODEL.h
  group USER/HAL/HAL_PCF8574
    ../USER/HAL/HAL_PCF8754/: HAL_PCF8574.cpp HAL_PCF8574.h
  group USER/HAL/HAL_SIM800C
    ../USER/HAL/HAL_SIM800C/: HAL_SIM800C.cpp HAL_SIM800C.h
  group USER/HAL/HAL_W25Q
    ../USER/HAL/HAL_W25Q/: HAL_W25Q.cpp HAL_W25Q.h
  group USER/LIB/LANG
    ../USER/LIB/LANG/: EN.c
  group USER/LIB/LIB_E70-868T30S
    ../USER/LIB/LIB_E70-868T30S/: LIB_E70-868T30S.cpp LIB_E70-868T30S.h
  group USER/LIB/LIB_FLASH
    ../USER/LIB/LIB_FLASH/: LIB_FLASH.cpp LIB_FLASH.h
  group USER/LIB/LIB_HC05
    ../USER/LIB/LIB_HC05/: HC05_SHORTCODES.h HC05_TYPEDEF.h LIB_HC05.cpp LIB_HC05.h
  group USER/LIB/LIB_LCD
    ../USER/LIB/LIB_LCD/: LIB_LCD.cpp LIB_LCD.h
  group USER/LIB/LIB_MODEL
    ../USER/LIB/LIB_MODEL/: LIB_MODEL.cpp LIB_MODEL.h
  group USER/LIB/LIB_NODEBOXRF868
    ../USER/LIB/LIB_NODEBOXRF868/: LIB_NODEBOXRF868.cpp LIB_NODEBOXRF868.h
  group USER/LIB/LIB_SDMMC
    ../USER/LIB/LIB_SDMMC/: LIB_SDMMC.cpp LIB_SDMMC.h
  group USER/LIB/LIB_SIM800C
    ../USER/LIB/LIB_SIM800C/: Bluetooth.cpp BluetoothUser.cpp GPRS.cpp GPRSUser.cpp Gsm.cpp GsmUser.cpp LIB_SIM800C.cpp LIB_SIM800C.h SIM800C_TYPEDEF.h Sim80xConfig.h Sim80xUser.cpp
  group USER/SETTINGS
    ../USER/SETTINGS/: Settings.h
  group USER/SRC
    ../USER/SRC/: Conversions.c Conversions.h Functions.c Functions.h Pinouts.h Shortcodes.h Variables.h
